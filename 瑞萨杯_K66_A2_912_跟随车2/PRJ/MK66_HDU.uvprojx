# Keil uVision project MK66_HDU.uvprojx, settings and files
target MK66_HDU (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MK66FX1M0xxx18 NXP
  pack: Keil.Kinetis_K60_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x1FFF0000,0x00010000) IROM(0x00000000,0x00100000) IROM2(0x10000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MK66_HDU
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3
  c include: ..\SRC\HARDWARE\inc;..\SRC\SMARTCAR\inc;..\SRC\STARTUP\CoreSupport;..\SRC\STARTUP\DeviceSupport;..\SRC\STARTUP\DeviceSupport\MDK-ARM;..\SRC\USER\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group STARTUP
    ../SRC/STARTUP/DeviceSupport/MDK-ARM/: startup_MK66F18.s
    ../SRC/STARTUP/DeviceSupport/: system_MK66.c
  group SMARTCAR
    ../SRC/SMARTCAR/src/: motor.c servo.c encoder.c smartcar_init.c buzzer.c key.c nrf2401.c MT9V032.c oled.c TrackType.c image_process.c control.c FindTrack.c HC_SR04.c
  group USER
    ../SRC/USER/src/: isr.c main.c
  group HARDWARE
    ../SRC/HARDWARE/src/: common.c dma.c dmacnt.c ftm.c gpio.c pit.c port.c systick.c uart.c misc.c
